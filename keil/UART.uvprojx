# Keil uVision project UART.uvprojx, settings and files
target G3519_UART (6240000::V6.24::ARMCLANG)
  device: MSPM0G3519 Texas Instruments
  pack: TexasInstruments.MSPM0GX51X_DFP.1.0.0
  cpu: IRAM(0x20000000,0x00010000) IRAM2(0x20100000,0x00010000) IROM(0x00000000,0x00080000) IROM2(0x00400000,0x00080000) XRAM(0x20200000,0x00020000) XRAM2(0x20300000,0x00010000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: UART +hex
  BeforeMake: cmd.exe /C "D:\TI\CCS2051\ccs\utils\sysconfig_1.27.1\sysconfig_cli.bat" --product "D:\TI\CCS2051\mspm0_sdk_2_10_00_04\.metadata\product.json" --device MSPM0G3519 --package "LQFP-80(PN)" --script "D:\BaiduNetdiskDownload\EVM_V2.0_Material_G3519\02_Demonstration\Experimental_Guide_Code\MyG3519Code\05_1_UART\project.syscfg" --output "D:\BaiduNetdiskDownload\EVM_V2.0_Material_G3519\02_Demonstration\Experimental_Guide_Code\MyG3519Code\05_1_UART\keil"
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=4
  c define: __MSPM0G3519__
  c include: ../;../../../../../../source/third_party/CMSIS/Core/Include;../../../../../../source;..\..\..\source;..\..\..\source\third_party\CMSIS\Core\Include;D:\TI\CCS2051\mspm0_sdk_2_10_00_04\source
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT5: ROM 0x400000 size 0x80000
  memory RVCT6: RAM 0x20200000 size 0x20000
  memory RVCT7: RAM 0x20300000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x10000
  memory RVCT10: RAM 0x20100000 size 0x10000
  scatter file: ./mspm0g3519.sct
  link misc: D:\TI\CCS2051\mspm0_sdk_2_10_00_04\source\ti\driverlib\lib\keil\m0p\mspm0gx51x\driverlib.a
  group Source
    ./: startup_mspm0g351x_uvision.s
    ../: ti_msp_dl_config.h ti_msp_dl_config.c main.c project.syscfg
